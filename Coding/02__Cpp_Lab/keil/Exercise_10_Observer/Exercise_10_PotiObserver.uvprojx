# Keil uVision project Exercise_10_PotiObserver.uvprojx, settings and files
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1768 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Exercise_10_PotiObserver
  AfterMake: cmd /c echo.>>WSTDeployer_CurrentFileList.txt
  c flags: Optim=1
  c include: .;GeneratedModel;RXF;RXF\oxf
  asm include: .;RXF;;RXF\oxf
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group GeneratedModel
    GeneratedModel/: class_5.cpp class_6.cpp Default.cpp Display.cpp LedBar.cpp MainMCB1700.cpp Poti.cpp PotiObserver.cpp PotiSubject.cpp WSTMonitor_sendTypes.cpp
  group RXF
    RXF/: RXF_BehaviorPkg.cpp WST_CFG_Highwater.cpp WST_MEM.cpp
    ./RXF/LIB/: RXFR.lib
target Release (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: GettingStarted
  BeforeMake: java -jar "C:\Users\Hochschule Ulm\Willert\RXF-Eval_Rpy-Cpp-ARM_V6.01\Tools\XMLCreator.jar" -sourceFolder "." -tool "Rhapsody" -destinationFile "./xmlData.xml" -targetConfigurationFile "C:\Users\Hochschule Ulm\Willert\RXF-Eval_Rpy-Cpp-ARM_V6.01\Tools\Target.xml" -measureTime -subFolders -language CPP
  AfterMake: cmd /c echo.>>WSTDeployer_CurrentFileList.txt
  c flags: Optim=1
  c include: .;GeneratedModel;RXF;RXF\oxf
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 5.0.1, Board Support:Graphic LCD 1.0.0, CMSIS Driver:SPI:SSP 2.7.0, Device:GPDMA 1.2.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
