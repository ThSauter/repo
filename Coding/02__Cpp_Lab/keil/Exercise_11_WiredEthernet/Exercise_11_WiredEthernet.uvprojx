# Keil uVision project Exercise_11_WiredEthernet.uvprojx, settings and files
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1768 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: GettingStarted
  c flags: Optim=1
  c misc: --diag_suppress=188
  c include: .;GeneratedModel;RXF;RXF\oxf
  asm include: .;RXF;GeneratedModel;RXF\oxf
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group GeneratedModel
    ./GeneratedModel/: ActiveController.cpp EthernetController.cpp ExamplePkg.cpp LED.cpp MainTargetComponent.cpp SequentialController.cpp TestBuilder.cpp WSTMonitor_sendTypes.cpp
  group oxf
    ./RXF/oxf/: omstring.cpp
  group RXF
    ./RXF/: RXF_BehaviorPkg.cpp WST_CFG_Highwater.cpp WST_ERR.cpp WST_EVT.cpp WST_FSM.cpp WST_MEM.cpp WST_MEM_Block.cpp WST_MSQ.cpp WST_MTX.cpp WST_OSW.cpp WST_PRT_Multi.cpp WST_RXF.cpp WST_TMM.cpp WST_TMR.cpp WST_TSK.cpp WSTForwardDecl.cpp WSTMonitor.cpp WSTMonitorIO_Keil_CortexM3_ITM.cpp WSTMonitorIO_Keil_CortexM3_UART.cpp WSTRTOS.cpp WSTTarget.cpp
target Release (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: GettingStarted
  c flags: Optim=1
  c include: .;GeneratedModel;RXF;RXF\oxf
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 5.0.1, CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, CMSIS:RTOS:Keil RTX 4.81.0, Network:CORE 7.4.0, Network:Interface:ETH 7.4.0, Network:Socket:BSD 7.4.0, Network:Socket:TCP 7.4.0, Network:Socket:UDP 7.4.0, CMSIS Driver:Ethernet MAC 2.9.0, CMSIS Driver:Ethernet MAC 2.9, CMSIS Driver:Ethernet PHY:DP83848C 6.1.0, Device:GPIO 1.1.0, Device:GPIO 1.1, Device:PIN 1.0.0, Device:PIN 1.0, Device:Startup 1.0.0
