# Keil uVision project GettingStarted.uvprojx, settings and files
target Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1768 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: GettingStarted
  c flags: Optim=1
  c misc: --diag_suppress=188
  c include: .;GeneratedModel;RXF;RXF\oxf
  asm include: .;RXF;GeneratedModel;RXF\oxf
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Release (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: GettingStarted
  c flags: Optim=1
  c include: .;GeneratedModel;RXF;RXF\oxf
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 5.0.0, CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, CMSIS:RTOS:Keil RTX 4.81.0, Device:Startup 1.0.0
