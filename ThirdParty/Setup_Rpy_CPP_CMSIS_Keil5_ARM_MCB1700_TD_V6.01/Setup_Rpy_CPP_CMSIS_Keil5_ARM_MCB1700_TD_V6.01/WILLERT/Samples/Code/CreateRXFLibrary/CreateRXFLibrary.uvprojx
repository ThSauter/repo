# Keil uVision project CreateRXFLibrary.uvprojx, settings and files
target RXFR (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1768 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.0.0
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RXFR (library)
  c flags: Optim=1
  c define: NDEBUG
  c include: .;..\..\..\Source;..\..\..\Source\oxf;.\KeilRTA
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group RXFSources
    ../../../Source/: WST_ERR.cpp WST_EVT.cpp WST_FSM.cpp WST_MEM_Block.cpp WST_MSQ.cpp WST_MTX.cpp WST_PRT_Multi.cpp WST_RXF.cpp WST_TMM.cpp WST_TMR.cpp WST_TSK.cpp WSTForwardDecl.cpp WSTMonitor.cpp WSTMonitorIO_Keil_CortexM3_ITM.cpp WSTMonitorIO_Keil_CortexM3_UART.cpp WSTRTOS.cpp WSTTarget.cpp
    ../../../Source/oxf/: omstring.cpp
  group Dimensioning_Files_-_Not_Included_in_LIB
    ../../../Source/: WST_CFG_Highwater.cpp WST_MEM.cpp
  group Container_Classes
    ../../../Source/oxf/: omstring.cpp
software components: CMSIS:CORE 3.30.0
