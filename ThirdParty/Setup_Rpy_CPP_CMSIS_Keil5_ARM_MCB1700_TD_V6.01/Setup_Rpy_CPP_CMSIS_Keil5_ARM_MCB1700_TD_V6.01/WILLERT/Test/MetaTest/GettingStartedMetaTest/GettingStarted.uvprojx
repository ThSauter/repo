# Keil uVision project GettingStarted.uvprojx, settings and files
target Debug (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: GettingStarted
  BeforeMake: "@RPYPROG_1@\jdk\jre\bin\java" -jar "@WILLERT_1@\@WST_RELEASE_NAME@\Tools\XMLCreator.jar" -sourceFolder "." -tool "Rhapsody" -destinationFile "./xmlData.xml" -targetConfigurationFile "@WILLERT_1@\@WST_RELEASE_NAME@\Tools\Target.xml" -measureTime -subFolders -language CPP
  AfterMake: cmd /c echo.>>WSTDeployer_CurrentFileList.txt
  c flags: Optim=4 oTime=1
  c include: .;GeneratedModel;RXF;RXF\oxf
  asm include: .;RXF;;RXF\oxf
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Debugging
    ../../../NotForRelease/: AutomatedKeilTestInSimulator.ini
    ./: DebugPrinter.c
  group ::Device
    RTE/Device/LPC1768/: startup_LPC17xx.s system_LPC17xx.c
target Release (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: GettingStarted
  BeforeMake: as above
  AfterMake: cmd /c echo.>>WSTDeployer_CurrentFileList.txt
  c flags: Optim=4 oTime=1
  c include: .;GeneratedModel;RXF;RXF\oxf
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
