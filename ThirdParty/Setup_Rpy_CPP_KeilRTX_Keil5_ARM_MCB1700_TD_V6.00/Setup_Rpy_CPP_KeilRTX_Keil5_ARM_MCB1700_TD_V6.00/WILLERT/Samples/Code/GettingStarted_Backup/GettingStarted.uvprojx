# Keil uVision project GettingStarted.uvprojx, settings and files
target Debug (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.1.0
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: GettingStarted
  AfterMake: cmd /c echo.>>WSTDeployer_CurrentFileList.txt
  c flags: Optim=1
  c include: .;GeneratedModel;"@KEIL_1@\ARM\RV31\INC";RXF;RXF\oxf
  asm include: .;RXF;;RXF\oxf
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group RTL
    @KEIL_1@/ARM/RV31/LIB/: RTX_CM3.lib
    ./: RTX_Config.c
target Release (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: GettingStarted
  AfterMake: cmd /c echo.>>WSTDeployer_CurrentFileList.txt
  c flags: Optim=1
  c include: .;GeneratedModel;"@KEIL_1@\ARM\RV31\INC";RXF;RXF\oxf
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
